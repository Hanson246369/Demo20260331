# Keil uVision project FP-24MF-DP.uvprojx, settings and files
target FP-24MF-DP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SH32F9001 Sinowealth
  pack: Sinowealth.SH3xF9xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x10000000-0x10003FFF) IROM(0x0000000-0x003FFFF) CLOCK(4000000~72000000) CPUTYPE("Cortex-M3")
  output: FP-24MF-DP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _MODULE_DBG_PRINTF,DEFAULT_ASSERT_ENABLE,_HEAD_FILE_SH32F9001
  c include: ..\..\Libraries\CMSIS\Device\Sinowealth\SH32F9xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\SH32F9xx_sb0_StdPeriph_Driver\1.0\inc;..\Program\uart;..\Program\user;..\Program\lcd;..\Program\timer;..\Program\eeprom;..\Program\iic;..\Program\beep;..\Program\key;..\Program\fault;..\Program\queue;..\Program\adc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group STARTCODE
    ../../Libraries/CMSIS/Device/Sinowealth/SH32F9xx/Source/Startup/arm/: startup_sh32f9001_keil.s
  group USER
    ../Program/user/: main.c interrupt.c sh32f9xx_sb0_retarget.c sh32f9xx_sb0_retarget.h app.c delay.c
  group HW_DRIVER
    ../Program/uart/: uart.c
    ../Program/lcd/: lcd.c
    ../Program/timer/: timer.c
    ../Program/eeprom/: eeprom.c
    ../Program/iic/: lpiic.c hpiic.c
    ../Program/beep/: beep.c
    ../Program/key/: key.c
    ../Program/fault/: fault.c
    ../Program/adc/: adc.c
  group Queue
    ../Program/queue/: queue.c
  group FWlib
    ../../Libraries/SH32F9xx_sb0_StdPeriph_Driver/1.0/src/: sh32f9xx_sb0_gpio.c sh32f9xx_sb0_iwdt.c sh32f9xx_sb0_rcc.c sh32f9xx_sb0_syscfg.c sh32f9xx_sb0_uart.c sh32f9xx_sb0_timer.c sh32f9xx_sb0_lcd.c sh32f9xx_sb0_nvic.c sh32f9xx_sb0_flash.c sh32f9xx_sb0_adc.c
  group CMSIS
    ../../Libraries/CMSIS/Device/Sinowealth/SH32F9xx/Source/: system_sh32f9xx_sb0.c
  group README
    ../../: readme.txt
